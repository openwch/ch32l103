# Keil uVision project FreeRTOS_Core.uvprojx, settings and files
target CH32F20x (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CH32F207VC WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F20x +hex
  c flags: Optim=4 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\SRC\StdPeriphDriver\inc;..\..\SRC\CMSIS;..\..\SRC\Debug;..\FreeRTOS_Core;.\FreeRTOS\Source\include;.\FreeRTOS\Source;.\FreeRTOS\Source\portable\MemMang;.\FreeRTOS\Source\portable\Common;.\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: ch32f20x_it.c Main.c system_ch32f20x.c
  group startup
    ../../SRC/Startup/: startup_ch32f20x_D8C.s
  group core
    ../../SRC/CMSIS/: core_cm3.c
  group debug
    ../../SRC/Debug/: debug.c
  group peripheral
    ../../SRC/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_dvp.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_fsmc.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_opa.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_sdio.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c
  group freertosfiles
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/Source/: timers.c tasks.c queue.c list.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
