# Keil uVision project TencentOS_Tiny_Core.uvprojx, settings and files
target CH32F20x (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: CH32F207VC WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F20x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\SRC\StdPeriphDriver\inc;..\..\SRC\CMSIS;..\..\SRC\Debug;..\TencentOS_Tiny_Core;.\TencentOS_tiny\arch\arm\arm-v7m\common;.\TencentOS_tiny\arch\arm\arm-v7m\cortex-m3\armcc;.\TencentOS_tiny\kernel\core;.\TencentOS_tiny\kernel\core\include;.\TencentOS_tiny\kernel\hal;.\TencentOS_tiny\kernel\hal\include;.\TencentOS_tiny\kernel\pm;.\TencentOS_tiny\kernel\pm\include;.\TencentOS_tiny\arch\arm\arm-v7m\common\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: ch32f20x_it.c Main.c system_ch32f20x.c
  group startup
    ../../SRC/Startup/: startup_ch32f20x_D8C.s
  group core
    ../../SRC/CMSIS/: core_cm3.c
  group debug
    ../../SRC/Debug/: debug.c
  group peripheral
    ../../SRC/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_dvp.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_fsmc.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_opa.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_sdio.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c
  group tos/arch
    ./TencentOS_tiny/arch/arm/arm-v7m/common/: tos_cpu.c
    ./TencentOS_tiny/arch/arm/arm-v7m/cortex-m3/armcc/: port_c.c port_s.S
  group tos/kernel
    ./TencentOS_tiny/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/config
    ./: tos_config.h
