# Keil uVision project CH32F20x.uvprojx, settings and files
target CH32F20x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH32F203RC WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F20x +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\SRC\CMSIS;..\..\..\..\SRC\Debug;..\..\..\..\SRC\Startup;..\..\..\..\SRC\StdPeriphDriver\inc;..\CH32F20x_IAP;.\user\USBLIB\CONFIG;.\user\USBLIB\USB-Driver\inc;.\user
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: ch32f20x_it.c flash.c iap.c Main.c system_ch32f20x.c ch32f20x_usbhs_device.c ch32f20x_usbfs_device.c
  group startup
    ../../../../SRC/Startup/: startup_ch32f20x_D6.s
  group core
    ../../../../SRC/CMSIS/: core_cm3.c
  group debug
    ../../../../SRC/Debug/: debug.c
  group peripheral
    ../../../../SRC/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c
  group usbcore
    ./user/USBLIB/USB-Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group usbconfig
    ./user/USBLIB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
