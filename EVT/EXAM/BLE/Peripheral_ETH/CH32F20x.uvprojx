# Keil uVision project CH32F20x.uvprojx, settings and files
target CH32F20x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH32F203RC WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F20x +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: CH32F20x_D8W
  c include: ..\..\SRC\StdPeriphDriver\inc;..\..\SRC\CMSIS;..\..\SRC\Debug;.\APP\include;..\HAL\include;..\LIB;.\includes;.\Profile\include;..\..\ETH\NetLib
  memory RVCT4: ROM 0x0 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\HAL\CH32F20x.sct
  group APP
    ./app/: ch32f20x_it.c system_ch32f20x.c
    ./APP/: eth.c peripheral.c peripheral_main.c
  group HAL
    ../HAL/: KEY.c LED.c MCU.c RTC.c SLEEP.c
  group config
    ../HAL/include/: config.h
  group LIB
    ../LIB/: wchble.lib
  group startup
    ../../SRC/Startup/: startup_ch32f20x_D8W.s
  group core
    ../../SRC/CMSIS/: core_cm3.c
  group debug
    ../../SRC/Debug/: debug.c
  group peripheral
    ../../SRC/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_dvp.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_fsmc.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_opa.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_sdio.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c ch32f20x_eth.c
  group Profile
    ./Profile/: devinfoservice.c gattprofile.c
  group ETH
    ../../ETH/NetLib/: wchnet.lib eth_driver_D8W.c
